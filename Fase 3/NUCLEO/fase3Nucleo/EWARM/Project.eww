<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\fase3Nucleo.ewp</path>
  </project>
  <batchBuild />
</workspace>
